## pkgs/hid-msi-claw-dkms/Kconfig
```kconfig
config HID_MSI_CLAW
    tristate "MSI Claw gamepad configuration support"
    depends on USB_HID
```
